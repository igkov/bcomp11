# Keil uVision project bcomp11.uvprojx, settings and files
target BCOMP11 (Debug) (ARM-ADS)
  device: LPC11C14FBD48/301 NXP
  pack: Keil.LPC1100_DFP.1.4.0
  cpu: IRAM(0x10000000,0x2000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: bcomp11 +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: CORTEX _DBGOUT _LPC1100_ CFG_VIRTUINO
  c include: .\
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group StartUp
    ./: startup_LPC11xx.s system_LPC11xx.c
  group src
    ./: beep.c can.c leds.c event.c printf.c timer.c buttons.c sounds.c eeprom.c config.c crc8.c lzss.c uart0.c adc.c analog.c elog.c virtuino.c sun.c
  group oled
    ./icons/: icons11.c
    ./: graph.c i2c.c oled128_sh1106.c oled128_ssd1306.c oled128.c wheels.c drive.c diagram.c
  group main
    ./: nmea.c bcomp.c obd.c errors.c bconfig.c bcomp.h menu.c warning.c
  group fonts
    ./fonts/: font6x8.c font12x16.c arial_30_pk.c arial_30b_pk.c arial_48_pk.c arial_48b_pk.c courier_30_pk.c courier_30b_pk.c courier_48_pk.c courier_48b_pk.c helv_30_pk.c helv_30b_pk.c helv_48_pk.c helv_48b_pk.c sans_30_pk.c sans_30b_pk.c sans_48_pk.c sans_48b_pk.c times_30_pk.c times_30b_pk.c times_48_pk.c times_48b_pk.c
target BCOMP11 Pajero (Release) (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: LPC11C14FBD48/301 NXP
  pack: Keil.LPC1100_DFP.1.4.0
  cpu: as above
  output: bcomp11 +hex
  c flags: Optim=3 v6Lang=1 v6LangP=1
  c define: CORTEX _LPC1100_ CFG_PAJERO
  c include: .\
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
target BCOMP11 Nissan (Release) (ARM-ADS)
  device: LPC11C14FBD48/301 NXP
  pack: Keil.LPC1100_DFP.1.4.0
  cpu: as above
  output: bcomp11 +hex
  c flags: Optim=3 v6Lang=1 v6LangP=1
  c define: CORTEX _LPC1100_ CFG_NISSAN
  c include: .\
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
target BCOMP11 Virtuino (Release) (ARM-ADS)
  device: LPC11C14FBD48/301 NXP
  pack: Keil.LPC1100_DFP.1.4.0
  cpu: as above
  output: bcomp11 +hex
  c flags: Optim=3 v6Lang=1 v6LangP=1
  c define: CORTEX _LPC1100_ CFG_VIRTUINO
  c include: .\
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
software components: CMSIS:CORE 4.3.0
